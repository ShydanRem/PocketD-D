#include "damage.h"
#include "magic.h"
#include "rest.h"
#include <assert.h>
#include <stdio.h>
#include <string.h>
static unsigned calls;
static uint32_t rng(void *p){(void)p;calls++;return 0;}
static void setup(pd_state *s){pd_demo(s);s->hp=s->max_hp=999;s->temp_hp=7;s->defences.configured=8191;s->resources[0].maximum=10;s->resources[0].current=5;s->magic.count=2;s->magic.powers[0]=(pd_power){.name="Magia",.flags=PD_PREPARED|PD_CONCENTRATES};s->magic.powers[1]=(pd_power){.name="Usi sintetici",.kind=1,.maximum=10,.remaining=5,.recovery=1};s->magic.concentration=1;}
static unsigned sub(unsigned a,unsigned b){return a>b?a-b:0;}
static unsigned def(unsigned a,unsigned f){if(f&4)return 0;if(f&1)a/=2;if(f&2)a*=2;return a;}
static void crc(uint8_t *p,size_t n){uint32_t c=pd_crc32(p,n-4);for(unsigned i=0;i<4;i++)p[n-4+i]=c>>(8*i);}
int main(void){
 static pd_state s,before,next,decoded;pd_damage_event_summary r,old;unsigned cases=0;const unsigned amounts[]={0,1,2,3,7,11,21,31};
 /* Independent balance/availability truth table in both phases and every profile slot. */
 for(unsigned slot=0;slot<3;slot++)for(unsigned stage=0;stage<2;stage++)for(unsigned kind=0;kind<3;kind++)for(unsigned cost=kind?1:0;cost<=(kind?10:0);cost++)for(unsigned available=0;available<=10;available++)for(unsigned spent=0;spent<2;spent++)for(unsigned reaction=0;reaction<2;reaction++)for(unsigned a=0;a<8;a++)for(unsigned flags=0;flags<8;flags++){
  setup(&s);s.resources[0].current=s.magic.powers[1].remaining=available;s.reaction_spent=spent;assert(pd_defence_set(&s,0,true,flags));pd_reduction_profile p={.value=3,.types=8191,.stage=stage,.active=true,.cost_kind=kind,.cost_index=kind==PD_COST_POWER?1:0,.cost=cost,.reaction=reaction};assert(pd_reduction_profile_set(&s,slot,p));
  pd_damage_event e={.count=1,.concentration=PD_CONCENTRATION_KEEP,.components={{0,amounts[a]}},.profile=slot+1,.allocation={stage?0:3}};before=s;assert(pd_damage_event_preview(&s,&e,&r));bool enough=(!kind||available>=cost)&&(!reaction||!spent);unsigned damage=stage?sub(def(amounts[a],flags),3):def(sub(amounts[a],3),flags);
  assert(r.total.configured==enough&&r.cost_missing==(kind&&available<cost)&&r.reaction_missing==(reaction&&spent)&&r.costs[0].before==(kind?available:0)&&r.costs[0].after==(kind?(enough?available-cost:available):0)&&r.reaction_before==spent&&r.reaction_after==(enough?(spent||reaction):spent));
  if(enough){assert(r.total.allowed&&r.total.adjusted==damage&&r.total.hp_after==sub(999,sub(damage,7)));assert(pd_damage_event_apply(&s,&e,&r)&&s.resources[0].current==available-(kind==PD_COST_COUNTER?cost:0)&&s.magic.powers[1].remaining==available-(kind==PD_COST_POWER?cost:0)&&s.reaction_spent==(spent||reaction)&&s.hp==r.total.hp_after&&s.temp_hp==r.total.temp_after&&pd_valid(&s));}
  else{old=r;next=s;calls=0;pd_roll roll;e.concentration=0;assert(!pd_damage_event_apply(&s,&e,&r)&&!memcmp(&s,&before,sizeof s)&&!memcmp(&r,&old,sizeof r));assert(!pd_concentration_event_roll(&s,&e,0,0,rng,NULL,&next,&roll,&r,false)&&!calls&&!memcmp(&next,&before,sizeof next));}
  cases++;
 }
 /* All counter/power references, names and spell/ability pool eligibility. */
 setup(&s);s.resource_count=8;for(unsigned i=0;i<8;i++){snprintf(s.resources[i].name,sizeof s.resources[i].name,"Contatore %u",i);s.resources[i].maximum=s.resources[i].current=999;assert(pd_reduction_cost_max(&s,PD_COST_COUNTER,i)==999);}s.magic.count=120;for(unsigned i=1;i<120;i++)s.magic.powers[i]=(pd_power){.name="Nome sintetico di quaranta caratteri ABC",.flags=PD_PREPARED|PD_LIMITED,.maximum=99,.remaining=99};
 for(unsigned kind=1;kind<=2;kind++)for(unsigned i=kind==1?0:1;i<(kind==1?8:120);i++){pd_reduction_profile p={.value=3,.types=8191,.active=true,.cost_kind=kind,.cost_index=i,.cost=1};assert(pd_reduction_profile_set(&s,0,p));pd_damage_event e={.count=1,.concentration=1,.components={{0,11}},.profile=1,.allocation={3}};assert(pd_damage_event_preview(&s,&e,&r)&&r.total.allowed&&r.costs[0].after==r.costs[0].before-1&&r.costs[0].name[40]==0);}
 assert(!pd_reduction_cost_max(&s,PD_COST_POWER,0)&&!pd_reduction_cost_max(&s,PD_COST_COUNTER,8)&&!pd_reduction_cost_max(&s,PD_COST_POWER,120)&&!pd_reduction_cost_max(NULL,1,0));
 /* Invalid rule/budget/eligibility, unavailable profiles and death guards never charge. */
 setup(&s);pd_reduction_profile p={.value=3,.types=1,.active=true,.cost_kind=1,.cost=2,.reaction=true};assert(pd_reduction_profile_set(&s,0,p));pd_damage_event e={.count=1,.components={{0,31}},.profile=1,.allocation={3}};
 for(unsigned reason=0;reason<6;reason++){setup(&s);assert(pd_reduction_profile_set(&s,0,p));e=(pd_damage_event){.count=1,.components={{0,31}},.profile=1,.allocation={3}};if(reason==0)s.reductions[0].active=false;if(reason==1)e.allocation[0]=4;if(reason==2)e.components[0].type=5;if(reason==3)s.reductions[0].rule=PD_RULE_MAGICAL;if(reason==4)pd_hp(&s,-9999);if(reason==5)e.components[0].amount=9999;before=s;next=s;calls=0;assert(pd_damage_event_preview(&s,&e,&r)&&!r.total.allowed);old=r;pd_roll roll;assert(!pd_damage_event_apply(&s,&e,&r)&&!memcmp(&s,&before,sizeof s)&&!memcmp(&r,&old,sizeof r));assert(!pd_concentration_event_roll(&s,&e,0,0,rng,NULL,&next,&roll,&r,false)&&!calls&&!memcmp(&next,&before,sizeof next));}
 /* One roll freezes resource/reaction and all damage in a single candidate. */
 setup(&s);p=(pd_reduction_profile){.value=3,.types=8191,.stage=1,.active=true,.concentration=1,.cost_kind=2,.cost_index=1,.cost=2,.reaction=true};assert(pd_reduction_profile_set(&s,0,p));e=(pd_damage_event){.count=1,.components={{0,31}},.profile=1};before=s;calls=0;pd_roll roll;assert(pd_concentration_event_roll(&s,&e,0,0,rng,NULL,&next,&roll,&r,false)&&calls==1&&next.hp==978&&!next.temp_hp&&next.magic.powers[1].remaining==3&&next.reaction_spent&&!next.magic.concentration&&!next.reductions[0].active&&r.total.concentration_dc==14&&r.costs[0].before==5&&r.costs[0].after==3&&r.profile_snapshot.cost==2&&r.profile_snapshot.reaction&&!memcmp(&s,&before,sizeof s));s=next;before=s;assert(!pd_damage_event_apply(&s,&e,&r)&&!memcmp(&s,&before,sizeof s));
 /* Explicit start turn changes only reaction; rounds and short/long rests do not. */
 before=s;assert(pd_reaction_change(&s,false)&&!s.reaction_spent&&s.magic.powers[1].remaining==before.magic.powers[1].remaining);assert(pd_reaction_change(&s,false)&&pd_reaction_change(&s,true));before=s;assert(!pd_reaction_change(&s,true)&&!memcmp(&s,&before,sizeof s)&&!pd_reaction_change(NULL,false));pd_round_summary tick;assert(pd_round_advance(&s,&tick)&&s.reaction_spent);assert(pd_rest_apply(&s,&(pd_rest_plan){0})&&s.reaction_spent&&s.magic.powers[1].remaining==10);assert(pd_rest_apply(&s,&(pd_rest_plan){.long_rest=true})&&s.reaction_spent);
 /* Valid reference declarations reject missing pools, empty charges and excess max. */
 setup(&s);before=s;const pd_reduction_profile bad[]={ {.cost_kind=3,.cost=1},{.cost_kind=0,.cost=1},{.cost_kind=0,.cost_index=1},{.cost_kind=1,.cost_index=8,.cost=1},{.cost_kind=2,.cost_index=0,.cost=1},{.cost_kind=1,.cost=11},{.cost_kind=2,.cost_index=1,.cost=11},{.cost_kind=2,.cost_index=1} };for(unsigned i=0;i<sizeof bad/sizeof *bad;i++)assert(!pd_reduction_profile_set(&s,0,bad[i])&&!memcmp(&s,&before,sizeof s));
 /* Largest PDD23 and all 16 appended bytes with valid CRC. */
 setup(&s);s.resources[0].current=s.resources[0].maximum=999;s.magic.count=120;for(unsigned i=2;i<120;i++)s.magic.powers[i]=(pd_power){.name="Magia",.flags=PD_PREPARED};for(unsigned i=0;i<3;i++)assert(pd_reduction_profile_set(&s,i,(pd_reduction_profile){.value=3,.types=8191,.active=true,.cost_kind=1,.cost=999,.reaction=true}));s.reaction_spent=true;static uint8_t data[PD_RECORD_SIZE];size_t n=pd_encode(&s,170,data);uint32_t gen;assert(n==PD_RECORD_SIZE&&!memcmp(data,"PDDN",4)&&pd_decode(data,n,&decoded,&gen)&&gen==170&&decoded.reaction_spent);for(unsigned i=0;i<3;i++)assert(decoded.reductions[i].cost_kind==1&&decoded.reductions[i].cost==999&&decoded.reductions[i].reaction);
 for(unsigned i=0;i<16;i++){pd_encode(&s,170,data);data[n-495+i]=i==15?2:(const unsigned[]){3,8,255,255,2}[i%5];crc(data,n);before=decoded;gen=17;assert(!pd_decode(data,n,&decoded,&gen)&&gen==17&&!memcmp(&decoded,&before,sizeof decoded));}
 pd_encode(&s,170,data);data[n-495]=2;crc(data,n);assert(!pd_decode(data,n,&decoded,&gen));
 printf("Profile costs: %u independent slot/stage/source/balance/cost/reaction/damage cases, every pool reference, one CON candidate, no-charge guards, explicit turn, unchanged round/rest and strict PDD23 corruption passed\n",cases);
}
